# Keil uVision project 测试.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S2139 Luminary Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: boot
  BeforeMake: armcc --device DLM -I . -E -o bl_config.inc bl_config.c
  AfterMake: fromelf --bin --output boot.BIN boot.AXF
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\bl_link.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: LM3S21xx_ssi.c bl_autobaud.c bl_check.c bl_main.c bl_packet.c bl_uart.c Disp.C LM3S21xx_gpio.c bl_startup_rvmdk.S
