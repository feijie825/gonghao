# Keil uVision project bootloader.uvproj, settings and files
target 引导 (ARM-ADS)
  device: LM3S2139 Luminary Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  BeforeMake: armcc --device DLM -I . -E -o bl_config.inc bl_config.c
  AfterMake: fromelf --bin -o .\output\bootloader.bin bootloader.axf
  c flags: Optim=2
  asm define: _BOOST_LDO_VOLTAGE,_CRYSTAL_FREQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\bl_link.sct
  link misc: --entry Reset_Handler
  group 库文件
    ./: bl_autobaud.c bl_check.c bl_main.c bl_packet.c bl_uart.c Disp.C LM3S21xx_gpio.c LM3S21xx_ssi.c
  group 启动文件
    ./: bl_startup_rvmdk.S
  group 说明
    ./: 说明.txt
