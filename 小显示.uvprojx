# Keil uVision project 小显示.uvprojx, settings and files
target DEBUG_IN_FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LM3S2139 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 新功耗 +hex
  AfterMake: fromelf --bin -o .\output\新功耗.bin 新功耗.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\debug_in_flash.sct
  link misc: --entry Reset_Handler
  group 库文件
    ./: LM3S21xx_can.c LM3S21xx_flash.c LM3S21xx_gpio.c LM3S21xx_interrupt.c LM3S21xx_mpu.c LM3S21xx_ssi.c LM3S21xx_sysctl.c LM3S21xx_systick.c LM3S21xx_timer.c LM3S21xx_uart.c LM3S21xx_watchdog.c LM3S21xx_adc.c
  group 启动文件
    ./: cpu_keil.S LM3S21xx_Vect.s
  group 应用文件
    ./: main.c Interrupt.C vari.c Init.C CAN.C UART.C ENG_ERR.C BitVari.C SOLID.C CS5460A.C
  group 说明
    ./: 说明.txt
target DEBUG_IN_RAM (ARM-ADS)
  device: LM3S2139 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: as above
  output: 小显示 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Lm3s2139
  asm include: ..\Lm3s2139
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry 0x20000101
